# Keil uVision project cubemx.uvprojx, settings and files
target cubemx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: cubemx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,NO_HOST
  c include: ../Inc;..\..\..\Drivers/STM32F7xx_HAL_Driver/Inc;..\..\..\Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;..\..\..\Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\..\..\Drivers/CMSIS/Include;..\..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\inc;..\..\boards\stm32f723e_disco;..\..\custom_bulk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f723xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ../../custom_bulk/: teeny_usb_desc.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group TeenyUSB
    ../../../src/: teeny_usb.c stm32_otg_init.c teeny_usb_stm32_otg_device.c
software components: CMSIS:CORE 4.3.0
