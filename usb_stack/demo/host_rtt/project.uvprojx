# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f723 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, STM32F723xx, RT_USING_ARM_LIBC,HSE_VALUE=25000000,USE_RTTHREAD,MSC_MEDIA_PACKET=4096
  c include: drivers;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\CMSIS\Include;applications;.;..\rt-thread\include;..\rt-thread\libcpu\arm\cortex-m7;..\rt-thread\libcpu\arm\common;..\rt-thread\components\libc\compilers\armlibc;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\finsh;..\boards\stm32f723e_disco;..\rt-thread\components\dfs\include;..\rt-thread\components\dfs\filesystems\romfs;..\..\inc;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\rt-thread\components\drivers\usb\usbhost\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Drivers
    drivers/: board.c drv_cache.c drv_mpu.c drv_sdram.c drv_usart.c
    ./drivers/: drv_qspi.c drv_teeny_usb.c
  group Applications
    applications/: main.c
    ./: teeny_usb_desc.c msc_cdc_desc.lua
  group Kernel
    ../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    ../rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
  group libc
    ../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c stdio.c
  group DeviceDrivers
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c waitqueue.c workqueue.c ringbuffer.c
  group finsh
    ../rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group board
    ../boards/stm32f723e_disco/: system_stm32f7xx_HSE25MHz.c startup_stm32f723xx.s
  group stm32_hal
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_dma.c stm32f7xx_ll_gpio.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
  group FileSystem
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group TeenyUSB
    ../../src/: stm32_otg_init.c teeny_usb.c teeny_usb_stm32_otg_device.c teeny_usb_stm32_otg_host.c
  group stm32_hal_msc
    ../../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_device
    ./drivers/: cdc_class.c usbd_storage_if.c msc_class.c teeny_usb_class.c
  group usb_host
    ./usbh_drv/: drv_usbh.c
    ../rt-thread/components/drivers/usb/usbhost/core/: core.c driver.c hub.c usbhost.c
    ../rt-thread/components/drivers/usb/usbhost/class/: hid.c mass.c udisk.c ukbd.c umouse.c
