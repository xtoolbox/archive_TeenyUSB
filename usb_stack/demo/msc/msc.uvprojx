# Keil uVision project msc.uvprojx, settings and files
target stm32f0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f1xx_bulk
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072,MSC_MEDIA_PACKET=2048
  c include: ..\..\inc;.;..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f0;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group teeny_usb_stack
    ../../src/: teeny_usb.c teeny_usb_stm32_fs_device.c teeny_usb_stm32_otg_device.c
  group app
    ./: usbd_storage_if.c msc.c teeny_usb_desc.c msc_class.c msc_desc.lua
  group stm32f0xx
    ../../src/: stm32f0_init.c
    ../boards/stm32f0/: startup_stm32f072.s system_stm32f0xx.c
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group stm32f1xx
    ../../src/: stm32f1_init.c
    ../boards/stm32f1/: system_stm32f10x.c startup_stm32f103xe.s
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group stm32f767zi_nucleo
    ../../src/: stm32f7_init.c
    ../boards/stm32f767zi_nucleo/: startup_stm32f767xx.s system_stm32f7xx.c
  group stm32f723e_disco
    ../../src/: stm32f7_init.c
    ../boards/stm32f723e_disco/: startup_stm32f723xx.s system_stm32f7xx_HSE25MHz.c
  group MSC
    ../../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
target stm32f1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1xx_bulk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,MSC_MEDIA_PACKET=2048
  c include: ..\..\inc;.;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f1;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target stm32f767zi_nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32f1xx_bulk
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,NO_HOST,MSC_MEDIA_PACKET=2048
  c include: ..\..\inc;.;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f767zi_nucleo;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
target stm32f723e_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: stm32f1xx_bulk
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000,NO_HOST,MSC_MEDIA_PACKET=2048
  c include: ..\..\inc;.;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f723e_disco;..\..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.1
